# Keil uVision project debug.uvproj, settings and files
target ROM (ARM-GNU)
  device: LPC1778 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: lpc1765_dbg
  group Source Group 1
    ../app/: debug.c main.c shell.c
target RAM (ARM-GNU)
  device: LPC1778 NXP (founded by Philips)
  cpu: as above
  output: lpc1765_dbg
